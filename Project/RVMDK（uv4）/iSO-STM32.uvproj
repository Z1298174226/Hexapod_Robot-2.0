# Keil uVision project iSO-STM32.uvproj, settings and files
target emWin_uCOSIII (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: emWin_fatfs +hex
  c flags: Optim=2 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\ff10;..\..\ff10\option;..\..\STemWinLibrary522\inc;..\..\STemWinLibrary522\Config;..\..\User\OS;..\..\User\BSP\spi;..\..\User\APP;..\..\User\BSP\lcd;..\..\User\BSP\led;..\..\User\BSP\kalman;..\..\User\BSP\delay;..\..\User\BSP\usart;..\..\User\BSP\SysTick;..\..\User\BSP;..\..\uCOSIII\uC-CPU;..\..\uCOSIII\uC-LIB;..\..\uCOSIII\uCOS-III\Ports;..\..\uCOSIII\uCOS-III\Source;..\..\User\BSP\key;..\..\User\BSP\24L01;..\..\User\BSP\CTL;..\..\User\BSP\PWM;..\..\User\BSP\TIM;..\..\User\BSP\UltrasonicWave;..\..\User\BSP;..\..\User\BSP\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: stm32f10x_it.c main.c
  group ff10
    ../../ff10/: diskio.c ff.c
    ../../ff10/option/: ccsbcs.c
  group STemWin_V522
    ../../STemWinLibrary522/OS/: GUI_X_Touch_Analog.c GUI_X_uCOS.c
    ../../STemWinLibrary522/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../../STemWinLibrary522/Lib/: STemWin522_CM3_OS_Keil.lib
  group BSP
    ../../User/BSP/led/: bsp_led.c
    ../../User/BSP/SysTick/: bsp_SysTick.c
    ../../User/BSP/usart/: bsp_usart1.c
    ../../User/BSP/key/: key.c bsp_exti.c
    ../../User/BSP/CTL/: control.c
    ../../User/BSP/PWM/: pwm.c
    ../../User/BSP/TIM/: TIM6.c
    ../../User/BSP/UltrasonicWave/: UltrasonicWave.c
    ../../User/BSP/: bsp.c bsp_i2c.c mpu6050.c
    ../../User/BSP/kalman/: kalman.c
    ../../User/BSP/spi/: fatfs_flash_spi.c
    ../../User/BSP/sdcard/: bsp_sdio_sdcard.c
    ../../User/BSP/lcd/: bsp_gpio_spi.c bsp_ili9341_lcd.c bsp_touch.c
  group APP
    ../../User/APP/: GUIDEMO_Fatfs.c GUIDEMO_Touch.c app.c
  group uCOS_Ports
    ../../uCOSIII/uCOS-III/Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uCOS_Source
    ../../uCOSIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uCOS_CPU
    ../../uCOSIII/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uCOS_LIB
    ../../uCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group uCOS_CFG
    ../../User/OS/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
